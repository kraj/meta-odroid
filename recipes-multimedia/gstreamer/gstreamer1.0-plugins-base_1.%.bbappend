INSANE_SKIP_libgstgl-1.0 = "file-rdeps"
INSANE_SKIP_gstreamer1.0-plugins-base-opengl = "file-rdeps"
