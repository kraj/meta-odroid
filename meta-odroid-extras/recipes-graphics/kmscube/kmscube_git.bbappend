RDEPENDS_kmscube =  "virtual/egl"
